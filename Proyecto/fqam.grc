options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: A
    orient: Qt.Horizontal
    start: '-1.5'
    step: (1.5)/100.
    stop: '1.5'
    value: '1.'
  states: {}
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Ruido
    orient: Qt.Horizontal
    start: '0'
    step: (4.)/50.
    stop: '4.'
    value: '0.'
  states: {}
- name: BW
  id: variable
  parameters:
    value: (Rs/2)*(1+Rolloff)
  states: {}
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: MiconstellationObject.points()
  states: {}
- name: F
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Frecuencia
    orient: Qt.Horizontal
    start: '-2.4'
    step: (2*2.4)/1000.
    stop: '2.4'
    value: '0.'
  states: {}
- name: Kf
  id: variable
  parameters:
    value: '200'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: digital.constellation_qpsk().points()
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: (0,1,2,3)
    type: calcdist
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: int(math.pow(2,NbpS))
  states: {}
- name: P
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Fase
    orient: Qt.Horizontal
    start: '-2.*math.pi'
    step: (4.*math.pi)/360.
    stop: 2.*math.pi
    value: '0.'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '100'
  states: {}
- name: Rb_0
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '160'
  states: {}
- name: Sps_0
  id: variable
  parameters:
    value: int(math.floor(samp_rate_to_usrp/Rs))
  states: {}
- name: Tupdate
  id: variable
  parameters:
    value: 1./Rb
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: h_rrc
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,Rolloff)
  states: {}
- name: mapdirect
  id: variable
  parameters:
    value: coding.direct_map(Constelacion)
  states: {}
- name: mapinverse
  id: variable
  parameters:
    value: coding.inverse_map(Constelacion)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(Rs*Sps)
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: samp_rate_to_usrp
  id: variable
  parameters:
    value: int(samp_rate_usrp_rx/512)
  states: {}
- name: samp_rate_usrp_rx
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: Tx_1_0_0_2_0_1
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: A
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: P
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: Ar
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: b_PSD_c_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '1e-5'
    gui_hint: 5,1,1,2
    samp_rate_audio: samp_rate
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1.'
    Spb: Sps
  states: {}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Kf*2*math.pi/samp_rate
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: coding
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy\nimport math\n#######################################################\n##        Done by Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n#######################################################\n##       Constellation map  identification           ##\n#######################################################                  \n# Constellation points are analyzed to determine the \n# the map used for ordering of the constellation points\ndef sum_modulus(a,b,modulus):\n    # realiza una suma de a y b en modulo modulus\n    return (a+b)%modulus\n\ndef angle_map(constellation_points):\n    # esta funcion entrega todos los angulos positivos entre 0 y 2pi\n    angles=numpy.angle(constellation_points)\n    return sum_modulus(angles, 2*math.pi, 2*math.pi)\n\ndef inverse_map(constellation_points):\n    M=len(constellation_points)\n    angles=angle_map(constellation_points)\n    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero\n    delta_angle= 2*math.pi/M     # angulo entre puntos\n    cod_inv=numpy.round(angles/delta_angle)\n    cod_inv=cod_inv.astype(numpy.int) #conversion a entero \n    return cod_inv\n\ndef direct_map(constellation_points):\n    M=len(constellation_points)\n    codinv=inverse_map(constellation_points)\n    coddirect=numpy.array([0]*M)\n    for j in range(M):\n        temp=numpy.where(codinv==j)\n        coddirect[j]=temp[0][0]\n    return coddirect\n\n\"\"\" # SECCION DE PRUEBAS DEL CODIGO\nimport gnuradio.digital as digital\nconstelacion=digital.constellation_8psk().points()\nprint(\"constelacion = \", constelacion)\nmapdirect=direct_map(constelacion)\nprint(\"codigo directo = \", mapdirect)\nmapinverse=inverse_map(constelacion)\nprint(\"codigo inverso = \", mapinverse)\n\"\"\"\n\n\n\n\n\n\n"
  states: {}
- name: d_freq_cf_assign_freq_cf_0
  id: d_freq_cf_assign_freq_cf
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: MiconstellationObject.points()
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: M
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: mapdirect
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homoero Ortega. Es un acumulador puro, va acumulando cada muestra entrante mientras entrega lo que lleva acumulado hasta el momento. Puede convertirse en un integrador si la salida se divide en la frecuencia de muestreo de la senal"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Accum_ff',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.memory=0.

          def work(self, input_items, output_items):
              """El acumulador"""
              in0=input_items[0]
              out0=output_items[0]
              L=len(in0)
              out0[:]=(self.memory+np.cumsum(in0))
              self.memory=out0[L-1]
              return len(out0)
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy.ma as ma
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    label1: '''.'''
    name: ''
    size: '8'
    type: complex
    update_time: Tupdate
    width1: '4'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    label1: '''.'''
    name: ''
    size: '8'
    type: complex
    update_time: Tupdate
    width1: '4'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,2
    label1: Re
    label2: Im
    name: '"Senal Modulada. Envolvente Compleja"'
    size: '1024'
    srate: (samp_rate)
    type: complex
    update_time: Tupdate
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,2,1,1
    label1: '''.'''
    name: '"Nivel de frecuencia"'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Frecuencia
    ymax: '2.5'
    ymin: '-2.5'
    yunit: Hz
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    label1: '''.'''
    name: '"Nivel de Fase"'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Fase
    ymax: 2*math.pi
    ymin: '-2*math.pi'
    yunit: radianes
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: '''.'''
    name: '"Nivel de Amplitud"'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,2
    label1: Mensaje
    label2: FSK parte real
    label3: FSK parte Imaginaria
    name: '"compararacion entre mensaje y EC"'
    nconnections: '3'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: Nuevo
    size: '1024'
    srate: samp_rate_audio
    type: float
    ymax: '128'
    ymin: '-128'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: P2a
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P2b
  states: {}
- name: vs_1
  id: virtual_sink
  parameters:
    stream_id: P3
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: P2a
  states: {}
- name: vso_0_0_0
  id: virtual_source
  parameters:
    stream_id: P2b
  states: {}
- name: vso_1
  id: virtual_source
  parameters:
    stream_id: P3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps,ntaps):
          h=ntaps*[0,]
          for n in range(Sps):
              k=int(ntaps/2) # esto es para que h[n] quede centrada en la mitad del vector
              h[k-n]=1.
          return h

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          ntaps_min=-int(ntaps/2)
          ntaps_max=abs(ntaps_min)-1+int(math.ceil(ntaps/2.-abs(ntaps_min)))
          h=ntaps*[0,]
          for n in range(ntaps):
              k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
              h[n]=numpy.sinc(k/Sps)
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [analog_const_source_x_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_const_source_x_0_0, '0', vs_0_0_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', vs_0_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [b_binary_bipolar_source_f_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', b_quantizer_fb_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', epy_block_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', vs_0, '0']
- [b_quantizer_fb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_add_xx_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0_0_0_1_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_throttle_0, '0', vs, '0']
- [d_freq_cf_assign_freq_cf_0, '0', blocks_multiply_xx_0, '1']
- [d_freq_cf_assign_freq_cf_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_chunks_to_symbols_xx, '0', b_PSD_c_0, '0']
- [digital_chunks_to_symbols_xx, '0', d_freq_cf_assign_freq_cf_0, '0']
- [digital_chunks_to_symbols_xx, '0', vs_1, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', Tx_1_0_0_2_0_1, '0']
- [e_VCO_fase_fc_0, '0', blocks_add_xx_1, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0_0_0_1_0_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx, '0']
- [vso, '0', blocks_complex_to_float_0, '0']
- [vso, '0', qtgui_const_sink_x_0, '0']
- [vso, '0', qtgui_time_sink_x_0, '0']
- [vso_0, '0', qtgui_time_sink_x_0_0, '0']
- [vso_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [vso_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [vso_1, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
